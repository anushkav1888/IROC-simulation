Commit message: unstable

File: src/my_robot_package/urdf/my_urdf.urdf (robot description, URDF)
Before this commit: robot iroc_rover, 9 links, 8 joints
Links:
- added link camera_link, mass 1; collision box size=0.4 0.4 0.4; visual box size=0.4 0.4 0.4
